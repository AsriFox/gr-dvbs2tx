options:
  parameters:
    author: AsriFox
    copyright: AsriFox
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
    title: DVB-S2 Transmitter test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '64800'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/asrifox/Downloads/overflowqpsk_276_45.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dvbs2tx_bbheader_bb_0
  id: dvbs2tx_bbheader_bb
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_MEDIUM
    goldcode: '0'
    pilots: PILOTS_ON
    rate_medium: C1_5_MEDIUM
    rate_normal: C1_4
    rate_short: C8_9
    rolloff: RO_0_15
  states: {}
- name: dvbs2tx_bbscrambler_bb_0
  id: dvbs2tx_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2tx_bch_bb_0
  id: dvbs2tx_bch_bb
  parameters: {}
  states: {}
- name: dvbs2tx_interleaver_bb_0
  id: dvbs2tx_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2tx_ldpc_bb_0
  id: dvbs2tx_ldpc_bb
  parameters: {}
  states: {}
- name: dvbs2tx_modulator_bc_0
  id: dvbs2tx_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2tx_physical_cc_0
  id: dvbs2tx_physical_cc
  parameters:
    dummyframes: DUMMY_FRAMES_OFF
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '64800'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', dvbs2tx_bbheader_bb_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [dvbs2tx_bbheader_bb_0, '0', dvbs2tx_bbscrambler_bb_0, '0']
- [dvbs2tx_bbscrambler_bb_0, '0', dvbs2tx_bch_bb_0, '0']
- [dvbs2tx_bch_bb_0, '0', dvbs2tx_ldpc_bb_0, '0']
- [dvbs2tx_interleaver_bb_0, '0', dvbs2tx_modulator_bc_0, '0']
- [dvbs2tx_ldpc_bb_0, '0', dvbs2tx_interleaver_bb_0, '0']
- [dvbs2tx_modulator_bc_0, '0', dvbs2tx_physical_cc_0, '0']
- [dvbs2tx_physical_cc_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
